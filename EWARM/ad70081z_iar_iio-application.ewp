# IAR project ad70081z_iar_iio-application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM410 AnalogDevices ADUCM410
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: _USE_STD_INT_TYPES; TINYIIOD_VERSION_MAJOR=0; TINYIIOD_VERSION_MINOR=1; TINYIIOD_VERSION_GIT=1.0; IIOD_BUFFER_SIZE=4096; TINYIIOD_API; ACTIVE_PLATFORM=ADUCM410_PLATFORM
  ICCARM.CCIncludePath2: ..\app; ..\app\ADUCM410_platform_drivers; ..\app\libtinyiiod; ..\app\no-OS\include; ..\app\no-OS\iio; ADuCM410_Hal_Driver; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ad70081z_iar_iio-application.hex
  ILINK.IlinkOutputFile: ad70081z_iar_iio-application.out
  ILINK.IlinkIcfFile: ADuCM410flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ADuCM410_HAL_Driver
    ADuCM410_HAL_Driver/: ClkLib.c common.c DioLib.c GptLib.c IntLib.c PwmLib.c PwrLib.h SpiLib.c UrtLib.c WdtLib.c
  group app
    ../app/: ad70081z.c ad70081z.h ad70081z_data_capture.c ad70081z_data_capture.h ad70081z_iio.c ad70081z_iio.h ad70081z_regs.c ad70081z_regs.h ad70081z_user_config.c ad70081z_user_config.h ADuCM410_Setup.c app_config.c app_config.h app_config_aducm410.c app_config_aducm410.h main.c
  group app/libtinyiiod
    ../app/libtinyiiod/: compat.h parser.c tinyiiod-private.h tinyiiod.c tinyiiod.h
  group app/no-OS/iio
    ../app/no-OS/iio/: iio.c iio.h iio_types.h
  group app/no-OS/include
    ../app/no-OS/include/: crc.h crc16.h crc24.h crc8.h delay.h error.h fifo.h gpio.h i2c.h irq.h list.h print_log.h pwm.h spi.h timer.h uart.h util.h
  group app/no-OS/util
    ../app/no-OS/util/: circular_buffer.c crc16.c crc24.c crc8.c fifo.c list.c util.c
  group app/platform_drivers
    ../app/ADuCM410_platform_drivers/: aducm410_delay.c aducm410_gpio.c aducm410_gpio.h aducm410_irq.c aducm410_irq.h aducm410_pwm.c aducm410_pwm.h aducm410_spi.c aducm410_spi.h aducm410_uart.c aducm410_uart.h errno.h
  group startup
    ./: startup_ADuCM410.s
    ADuCM410_HAL_Driver/: system_ADuCM410.c
